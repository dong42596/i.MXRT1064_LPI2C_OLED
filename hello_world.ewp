# IAR project hello_world.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; utilities; xip; BSP; BSP\LED; BSP\OLED
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; utilities; xip
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_sdram.icf
configuration sdram_txt_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_sdram_txt.icf
configuration ram_0x1400_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: evkmimxrt1064/demo_apps/hello_world/linker/MIMXRT1064xxxxx_ram_0x1400.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_sdram.icf
configuration sdram_txt_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; NDEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064/iar/MIMXRT1064xxxxx_sdram_txt.icf
configuration ram_0x1400_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: as above
  group (top)
    ./: hello_world.mex
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group BSP/LED
    BSP/LED/: bsp_led.c bsp_led.h
  group BSP/OLED
    BSP/OLED/: bsp_i2c_oled.c bsp_i2c_oled.h DEV_Config.c DEV_Config.h font12.c font16.c font20.c font24.c font8.c fonts.h OLED_Driver.c OLED_Driver.h OLED_GUI.c OLED_GUI.h
  group CMSIS
    CMSIS/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group doc
    doc/: readme.md
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h
  group evkmimxrt1064
    evkmimxrt1064/: evkmimxrt1064.mac evkmimxrt1064_sdram_init.mac
  group evkmimxrt1064/demo_apps/hello_world
    evkmimxrt1064/demo_apps/hello_world/: hello_world.bin
  group evkmimxrt1064/demo_apps/hello_world/linker
    evkmimxrt1064/demo_apps/hello_world/linker/: MIMXRT1064xxxxx_ram_0x1400.icf
  group MIMXRT1064/iar
    MIMXRT1064/iar/: MIMXRT1064xxxxx_flexspi_nor.icf MIMXRT1064xxxxx_ram.icf MIMXRT1064xxxxx_sdram.icf MIMXRT1064xxxxx_sdram_txt.icf
  group source
    source/: hello_world.c
  group startup
    startup/: startup_MIMXRT1064.s
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
  group xip
    xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
